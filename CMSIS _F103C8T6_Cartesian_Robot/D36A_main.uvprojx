# Keil uVision project D36A_main.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: D36A_main
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: stepper.c main.c vision.c pid.c track.c frame.c mcu_link.c yaw_track.c servo.c backlight.c lcd.c qr_scan.c mcu_cmd.c auto_place.c
  group New Group
    ./: stepper.h track_config.h vision.h pid.h track.h frame.h mcu_link.h link_config.h yaw_track.h servo.h backlight.h lcd.h cnfont.h qr_scan.h mcu_cmd.h auto_place.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
